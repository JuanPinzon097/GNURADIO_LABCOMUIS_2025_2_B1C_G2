options:
  parameters:
    generate_options: qt_gui
    id: misio6fm
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 25e6/32
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.1'
    freq: '19000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: '192 '
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: '384 '
    tau: '75e-6'
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: '48000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\VICTUS\Desktop\Audio de WhatsApp 2025-10-07 a las 19.29.06_b7cf8ef7.wav
    nchan: '2'
    repeat: 'True'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    nconnections: '5'
    type: float
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    nconnections: '3'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(audio_rate)
    interp: int(samp_rate)
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: int(audio_rate)
    interp: int(samp_rate)
    type: fff
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: '89000000'
    gain0: '30'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: L
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: R
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: PILOTO
  states: {}
- name: virtual_sink_1_0_0
  id: virtual_sink
  parameters:
    stream_id: L-R
  states: {}
- name: virtual_sink_1_0_0_0
  id: virtual_sink
  parameters:
    stream_id: L+R
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: L*R
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: L
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: L
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: L
  states: {}
- name: virtual_source_1_1
  id: virtual_source
  parameters:
    stream_id: R
  states: {}
- name: virtual_source_1_2
  id: virtual_source
  parameters:
    stream_id: PILOTO
  states: {}
- name: virtual_source_1_3
  id: virtual_source
  parameters:
    stream_id: L+R
  states: {}
- name: virtual_source_1_4
  id: virtual_source
  parameters:
    stream_id: L-R
  states: {}
- name: virtual_source_1_5
  id: virtual_source
  parameters:
    stream_id: L
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: R
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: R
  states: {}
- name: virtual_source_3_0
  id: virtual_source
  parameters:
    stream_id: R
  states: {}
- name: virtual_source_3_0_0
  id: virtual_source
  parameters:
    stream_id: PILOTO
  states: {}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: L-R
  states: {state: disabled}
- name: virtual_source_5
  id: virtual_source
  parameters:
    stream_id: L
  states: {}
- name: virtual_source_6
  id: virtual_source
  parameters:
    stream_id: R
  states: {}

connections:
- [analog_sig_source_x_0, '0', virtual_sink_1_0, '0']
- [analog_wfm_tx_0, '0', qtgui_freq_sink_x_1, '0']
- [analog_wfm_tx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_add_xx_0, '0', virtual_sink_1_0_0_0, '0']
- [blocks_float_to_complex_0, '0', uhd_usrp_sink_0, '0']
- [blocks_multiply_xx_0, '0', virtual_sink_2, '0']
- [blocks_sub_xx_0, '0', virtual_sink_1_0_0, '0']
- [blocks_wavfile_source_0, '0', audio_sink_0, '0']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_0, '0']
- [blocks_wavfile_source_0, '1', audio_sink_0, '1']
- [blocks_wavfile_source_0, '1', rational_resampler_xxx_0_0, '0']
- [rational_resampler_xxx_0, '0', virtual_sink_0, '0']
- [rational_resampler_xxx_0_0, '0', virtual_sink_1, '0']
- [virtual_source_0, '0', blocks_add_xx_0, '0']
- [virtual_source_1, '0', blocks_sub_xx_0, '0']
- [virtual_source_1_0, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_1_1, '0', qtgui_freq_sink_x_0, '1']
- [virtual_source_1_2, '0', qtgui_freq_sink_x_0, '2']
- [virtual_source_1_3, '0', qtgui_freq_sink_x_0, '3']
- [virtual_source_1_4, '0', qtgui_freq_sink_x_0, '4']
- [virtual_source_1_5, '0', qtgui_time_sink_x_1, '0']
- [virtual_source_2, '0', blocks_add_xx_0, '1']
- [virtual_source_3, '0', blocks_sub_xx_0, '1']
- [virtual_source_3_0, '0', qtgui_time_sink_x_1, '1']
- [virtual_source_3_0_0, '0', qtgui_time_sink_x_1, '2']
- [virtual_source_4, '0', analog_wfm_tx_0, '0']
- [virtual_source_4, '0', blocks_float_to_complex_0, '0']
- [virtual_source_5, '0', blocks_multiply_xx_0, '1']
- [virtual_source_6, '0', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
